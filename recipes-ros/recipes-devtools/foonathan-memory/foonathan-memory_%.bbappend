
LIC_FILES_CHKSUM = "file://LICENSE;md5=b68ca6474a0f8d6c83a635ef86bcd757"
SRCREV_main = "19ab0759c7f053d88657c0eb86d879493f784d61"
FILES:${PN}-dev += "*.a"
FILES:${PN}-staticdev += "*.a"

