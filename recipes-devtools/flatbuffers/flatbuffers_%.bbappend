
TOOLCHAIN_HOST_TASK_append = " nativesdk-flatbuffers-compiler"

