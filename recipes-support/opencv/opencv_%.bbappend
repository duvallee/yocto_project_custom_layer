
PACKAGECONFIG_append := "dnn text "
# PARALLEL_MAKE = ""
PARALLEL_MAKEINST = ""
