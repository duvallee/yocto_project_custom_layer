RPIFW_DATE = "20210430"
SRCREV = "518ee7c871aaa9aaa88116953d57e73787ee6e43"

SRC_URI[sha256sum] = "9379b3a035b7244f556a61cecd9caa27cccc30c0c1fb5ad1a618d904aad32ade"

