
#
EXTRA_OECMAKE += "-DUAGENT_USE_SYSTEM_FASTDDS=off -DUAGENT_USE_SYSTEM_FASTCDR=off -DUAGENT_USE_SYSTEM_LOGGER=off -DUAGENT_P2P_PROFILE=off"

