#
#
#
# --------------------------------------------------------------------------------------------------------------------
SUMMARY = "SDK for JETSON-NANO image"

# --------------------------------------------------------------------------------------------------------------------
LICENSE = "CLOSE"

# --------------------------------------------------------------------------------------------------------------------
require recipes-core/images/image-jetson-nano.bb


# --------------------------------------------------------------------------------------------------------------------
inherit populate_sdk_qt5


