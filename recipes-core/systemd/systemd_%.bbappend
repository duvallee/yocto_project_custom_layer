#
#
#

# ============================================================
RDEPENDS_${PN}_append = " wpa-supplicant "

# ============================================================
PACKAGECONFIG_append = " networkd resolved"

